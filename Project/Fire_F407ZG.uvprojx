# Keil uVision project Fire_F407ZG.uvprojx, settings and files
target STM32F407ZG-Demo (6240000::V6.24::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Fire_F407ZG +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,NES_SD_LIBRARY
  c misc: -O2
  c include: ..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_HAL_Driver\Inc;..\User;..\User\uart;..\User\tim;..\User\dwt;..\User\sram;..\User\lcd;..\User\led;..\User\key;..\User\beep;..\User\joystick;..\User\game;..\User\render;..\User\nes;..\User\audio;..\User\sdio;..\User\fatfs
  asm include: ..\User\nes
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_HAL_Driver
    ../Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_ll_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_ll_usart.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_sram.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c
  group USER
    ../User/: main.c stm32f4xx_it.c
    ../User/led/: bsp_led.c
    ../User/key/: bsp_key.c bsp_touchpad.c
    ../User/beep/: bsp_beep.c
    ../User/uart/: bsp_uart1.c
    ../User/dwt/: bsp_dwt.c
    ../User/sram/: bsp_sram.c
    ../User/lcd/: bsp_lcd_display.c bsp_lcd_tp_i2c.c nt35510.c ili9806g.c gtxxx.c pixel_font.c lcd_draw.c lcd_touch.c fonts.c
    ../User/joystick/: bsp_joystick.c
  group DOC
    ../Doc/: readme.txt
  group NES Emulator
    ../User/nes/: nes_library.c nes_import.c cjk_font.c 6502.s cart.s nes_fds_image.c nes_fds_audio.c nes_mmc5_audio.c nes_main.c nes_mapper.c nes_ppu.c nes_port.c nes_roms.c nes_fds_bios.c nes_posters.c nes_menu.c
    ../User/sdio/: bsp_sdio.c
    ../User/fatfs/: ff.c ffunicode.c diskio.c
    ../Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_sd.c stm32f4xx_ll_sdmmc.c
  group NES audio
    ../User/audio/: bsp_nes_audio.c
    ../User/nes/: nes_apu.c
    ../Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c
